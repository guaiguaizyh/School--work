# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c supersonic.c 1602.c
    ../../../../../../传感器_普中电路板_工程模板20240423/传感器_普中电路板_工程模板20240420/project/app/: timer.c delay.c alarm.c
