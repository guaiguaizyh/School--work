# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app;.\drive
  group Source Group 1
    ./: STARTUP.A51
    ./drive/: button.c beep.c led8.c timer.c
  group app
    ./app/: main.c
  group drive
    ./drive/: smg1.c delay.c
  group doc
    ./doc/: readme.txt
