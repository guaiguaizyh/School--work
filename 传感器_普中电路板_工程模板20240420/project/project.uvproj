# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app
  group Source Group 1
    ./: STARTUP.A51
    ./app/: main.c delay.c timer.c alarm.c 1602.c supersonic.c seg.c
